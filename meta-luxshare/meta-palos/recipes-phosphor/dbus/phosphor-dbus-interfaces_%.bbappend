FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
    file://0001-Add-the-enumeration-element-CPLD.patch \
	file://0001-Supports-fan-manual-mode.patch \
"
