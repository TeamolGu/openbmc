OBMC_IMAGE_EXTRA_INSTALL:append:palos = " \
    webui-vue \
    me-time-sync \
    static-mac-addr \
    phosphor-virtual-sensor \
    phosphor-inventory-manager \
"
