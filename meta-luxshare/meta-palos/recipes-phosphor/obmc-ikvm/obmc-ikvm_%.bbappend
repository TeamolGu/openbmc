FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Use latest revision
SRCREV = "a6a4da401acef16c2149e91853a9e0595a7c7fb6"

