
SRC_URI = "git://10.53.19.12/openbmc/webui-vue.git;branch=master;protocol=http"
#SRCREV = "${AUTOREV}"
#SRCREV = "1fcbe60ac9cb830e3391c3ad4394e330a25fee39"
SRCREV = "fedc7344df80d87050966a4903f7aff32fddd259"

